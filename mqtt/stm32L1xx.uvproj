# Keil uVision project stm32L1xx.uvproj, settings and files
target stm32L1xx (ARM-ADS)
  device: STM32L151RC STMicroelectronics
  cpu: IROM(0x08000000,0x00040000) IRAM(0x20000000,0x00008000) CPUTYPE("Cortex-M3") CLOCK(32000000) ELITTLE
  output: stm32L1xx +hex
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32L1XX_MD
  c include: .\user;.\app;.\app\BT;.\Libraries\CMSIS\core;.\Libraries\CMSIS\device;.\Libraries\CMSIS\device\startup;.\Libraries\STM32L1xx_StdPeriph_Driver\inc;.\Libraries\STM32L1xx_StdPeriph_Driver\src;.\user\Version_Contrl;.\user\Version_Contrl\Hardware_Version;.\user\Version_Contrl\Software_Version;.\app\sensor;.\rtos;.\rtos\include;.\rtos\portable;.\rtos\portable\MemMang;.\app\mqtt
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --diag_suppress=L6329
  group user
    ./user/: main.c stm32l1xx_it.c freertosSys.c systick.c
  group app
    ./app/: led.c rtc.c usart.c iwdg.c mqtt_usart.c dma.c
  group lib
    ./Libraries/STM32L1xx_StdPeriph_Driver/src/: misc.c stm32l1xx_adc.c stm32l1xx_aes.c stm32l1xx_aes_util.c stm32l1xx_comp.c stm32l1xx_crc.c stm32l1xx_dac.c stm32l1xx_dbgmcu.c stm32l1xx_dma.c stm32l1xx_exti.c stm32l1xx_flash.c stm32l1xx_flash_ramfunc.c stm32l1xx_fsmc.c stm32l1xx_gpio.c stm32l1xx_i2c.c stm32l1xx_iwdg.c stm32l1xx_lcd.c stm32l1xx_opamp.c stm32l1xx_pwr.c stm32l1xx_rcc.c stm32l1xx_rtc.c stm32l1xx_sdio.c stm32l1xx_spi.c stm32l1xx_syscfg.c stm32l1xx_tim.c stm32l1xx_usart.c stm32l1xx_wwdg.c
  group CMSIS
    ./Libraries/CMSIS/core/: core_cm3.c
    ./Libraries/CMSIS/device/: system_stm32l1xx.c
  group startup
    ./Libraries/CMSIS/device/startup/: startup_stm32l1xx_hd.s startup_stm32l1xx_md.s startup_stm32l1xx_mdp.s startup_stm32l1xx_xl.s
  group doc
    ./doc/: readme.txt
  group rtos
    ./rtos/: croutine.c list.c tasks.c timers.c queue.c event_groups.c
    ./rtos/portable/: port.c
    ./rtos/portable/MemMang/: heap_4.c
  group mqtt
    ./app/mqtt/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
