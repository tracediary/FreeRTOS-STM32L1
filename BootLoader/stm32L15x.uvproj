# Keil uVision project stm32L15x.uvproj, settings and files
target stm32L15x (ARM-ADS)
  device: STM32L151RB STMicroelectronics
  cpu: IROM(0x08000000,0x00020000) IRAM(0x20000000,0x00004000) CPUTYPE("Cortex-M3") CLOCK(32000000) ELITTLE
  output: stm32L15x +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32L1XX_MD
  c include: .\user;.\app;.\Libraries\CMSIS\core;.\Libraries\CMSIS\device;.\Libraries\CMSIS\device\startup;.\Libraries\STM32L1xx_StdPeriph_Driver\inc;.\Libraries\STM32L1xx_StdPeriph_Driver\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --diag_suppress=L6329
  group user
    ./user/: main.c stm32l1xx_it.c
  group app
    ./app/: iap.c sys.c usart.c eeprom.c
  group lib
    ./Libraries/STM32L1xx_StdPeriph_Driver/src/: misc.c stm32l1xx_flash.c stm32l1xx_syscfg.c stm32l1xx_rcc.c stm32l1xx_gpio.c stm32l1xx_usart.c
  group CMSIS
    ./Libraries/CMSIS/core/: core_cm3.c
    ./Libraries/CMSIS/device/: system_stm32l1xx.c
  group startup
    ./Libraries/CMSIS/device/startup/: startup_stm32l1xx_md.s
  group doc
    ./doc/: readme.txt
